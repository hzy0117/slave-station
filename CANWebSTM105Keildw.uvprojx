# Keil uVision project CANWebSTM105Keildw.uvprojx, settings and files
target CANWebSTMF105 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F105VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CANWebSTMF105 +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: .\StdPeriph_Driver\inc;.\Device\Include;.\Device\Source\ARM;.\user;.\user\FATFS;.\user\FATFS\option
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Library
    ./StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_flash.c misc.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_spi.c
    ./Device/Include/: stm32f10x.h
    ./Device/Source/ARM/: startup_stm32f10x_cl.s
    ./Device/Source/: system_stm32f10x.c
  group Source Files
    ./user/: main.cpp stm32f10x_conf.h stm32f10x_it.h main_CLS_DIDOAIAO.h main_CLS_DIDOAIAO.cpp mapping.c bsp_usart.c bsp_spi.c app.cpp jiexi.c
  group LibYX
    ./user/: YXF105GY_CLS_CANWeb2.H YXF105GY_CLS_CANWeb2.lib
  group 调试记录
    ./user/: STM32F105RBT6模板工程.txt
software components: CMSIS:CORE 5.6.0
